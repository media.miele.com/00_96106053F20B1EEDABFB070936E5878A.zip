Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-09T12:38:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 09 12:38:41 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a4ade766-bad8-4bb0-ae7c-062ff5175207\338b8b85-88aa-4442-8868-e4354f63044e\ifc * Database version: 5507 * Database creation date: Thu Feb 09 12:38:40 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 09 12:38:41 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 09 12:38:41 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 06012090_GB_HM16-80:53168003_GB_6012090_HM16-80, (2)
In: Default
Type - Material: z_Miele_Design_BRWS
Type - Pset_BuildingElementProxyCommon - Reference: 53168003_GB_6012090_HM16-80
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 53168003_GB_6012090_HM16-80
Material: z_Miele_Design_BRWS, z_Miele_Design_CLST, z_Miele_Connection_Water_IN, z_Miele_Connection_Connection_Modul, Roller
Pset_BuildingElementProxyCommon - sets with these values: 2
